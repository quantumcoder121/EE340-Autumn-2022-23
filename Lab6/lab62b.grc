options:
  parameters:
    generate_options: qt_gui
    id: lab62b
    output_language: python
    title: lab62b
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2560000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 1.12e9+1.25e6*0
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
