options:
  parameters:
    generate_options: qt_gui
    id: lab1c
    output_language: python
    title: lab1c
  states: {}

blocks:
- name: range0
  id: variable_qtgui_range
  parameters:
    label: r0
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: range1
  id: variable_qtgui_range
  parameters:
    label: r1
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: range2
  id: variable_qtgui_range
  parameters:
    label: r2
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: range3
  id: variable_qtgui_range
  parameters:
    label: r3
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: range4
  id: variable_qtgui_range
  parameters:
    label: r4
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: range0
    high_cutoff_freq: '500'
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: range4
    high_cutoff_freq: '15000'
    interp: '1'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    gain: range2
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    gain: range1
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_3
  id: band_pass_filter
  parameters:
    gain: range3
    high_cutoff_freq: '9000'
    interp: '1'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Bach.wav
    repeat: 'True'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '4']
- [band_pass_filter_0_1, '0', blocks_add_xx_0, '2']
- [band_pass_filter_0_2, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_3, '0', blocks_add_xx_0, '3']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_3, '0']

metadata:
  file_format: 1
