options:
  parameters:
    generate_options: qt_gui
    id: lab1d
    output_language: python
    title: lab1d
  states: {}

blocks:
- name: r0
  id: variable_qtgui_range
  parameters:
    label: r0
    start: '30'
    step: '1'
    stop: '2000'
    value: '900'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: r0
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8200'
    interp: '1'
    low_cutoff_freq: '7800'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: shor.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', blocks_throttle_0, '0']
- [band_reject_filter_0, '0', band_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_reject_filter_0, '0']

metadata:
  file_format: 1
