options:
  parameters:
    generate_options: qt_gui
    id: lab83
    output_language: python
    title: lab83
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    label: alpha
    start: '0'
    step: '0.001'
    stop: '1'
    value: '1'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: amp
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    label: sps
    rangeType: int
    start: '0'
    step: '1'
    stop: '16'
    value: '8'
  states: {}
- name: sym_rate
  id: variable_qtgui_range
  parameters:
    label: sym_rate
    rangeType: int
    start: '1600'
    step: '1'
    stop: '160000'
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '2000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '2000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: received.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: message.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '19'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sym_rate*sps
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: float
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: float
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: float
  states: {}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: float
  states: {}
- name: blocks_throttle_0_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: '2000000'
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-0.5, 0.5)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    gain: '1'
    interp: '1'
    samp_rate: '2000000'
    type: interp_fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sym_rate*sps
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '0'
    fftsize: '1024'
    name: Input to Receiver
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '0'
    fftsize: '1024'
    name: Filtered and Thresholded
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '0'
    fftsize: '1024'
    name: bits
    type: float
  states: {}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '0'
    fftsize: '1024'
    name: Demodulated
    type: float
  states: {}
- name: qtgui_sink_x_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '0'
    fftsize: '1024'
    name: Demodulated
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '16'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: 11*sps
    samp_rate: sym_rate*sps
    sym_rate: sym_rate
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: '1'
    ntaps: 11*sps
    samp_rate: sym_rate*sps
    sym_rate: sym_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_threshold_ff_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_throttle_0_0_1, '0', qtgui_sink_x_0_0_1, '0']
- [blocks_throttle_0_0_1_0, '0', qtgui_sink_x_0_0_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_uchar_0, '0']
- [fir_filter_xxx_0, '0', blocks_throttle_0_0_0_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', blocks_throttle_0_0_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_throttle_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_threshold_ff_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_throttle_0_0_1_0, '0']

metadata:
  file_format: 1
